# Keil uVision project rtos.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F303RE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.3
  cpu: IRAM(0x20000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtos +hex
  AfterMake: fromelf --bin --output ZH3_V1_2_FLASH.bin .\Objects\rtos.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F30X_HD
  c include: .\freeRTOS\include;.\freeRTOS\portable\RVDS\ARM_CM4F;.\freeRTOS\scr;.\app\inc;.\RTE\Device\GD32F303VE;.\dsp\Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ./app/scr/: config.c int.c main.c flash.c lcd.c encoder.c menu.c wdg.c user_data.c i2c.c ir.c usart.c xmos.c fmc.c
  group freertos
    ./freeRTOS/scr/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freerots/portable
    ./freeRTOS/portable/MemMang/: heap_4.c
    ./freeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group include
    ./app/inc/: config.h FreeRTOSConfig.h int.h flash.h lcd.h picture.h st7789.h adc.h encoder.h i2c.h ir.h menu.h test.h user_data.h wdg.h xmos.h fmc.h usart.h
  group New Group
    ./app/inc/: adc.h config.h encoder.h flash.h FreeRTOSConfig.h i2c.h int.h key_scan.h lcd.h menu.h picture.h st7789.h test.h user_data.h wdg.h
  group picture
    ./app/picture/: picture_bottom_left.c picture_bottom_right.c picture_little_num.c picture_menu_1.c picture_menu_2.c picture_menu_3.c picture_menu2_io_fun.c picture_menu3_io_fun.c picture_num.c picture_power_remote.c picture_top_left.c picture_top_right.c picture_menu_4.c picture_menu_5.c
software components: CMSIS:CORE 5.1.1, Device:GD32F30x_StdPeripherals:ADC 2.2.0, Device:GD32F30x_StdPeripherals:BKP 2.2.0, Device:GD32F30x_StdPeripherals:CAN 2.2.0, Device:GD32F30x_StdPeripherals:CRC 2.2.0, Device:GD32F30x_StdPeripherals:CTC 2.2.0, Device:GD32F30x_StdPeripherals:DBG 2.2.0, Device:GD32F30x_StdPeripherals:DMA 2.2.0, Device:GD32F30x_StdPeripherals:ENET 2.2.0, Device:GD32F30x_StdPeripherals:EXMC 2.2.0, Device:GD32F30x_StdPeripherals:EXTI 2.2.0, Device:GD32F30x_StdPeripherals:FMC 2.2.0, Device:GD32F30x_StdPeripherals:FWDGT 2.2.0, Device:GD32F30x_StdPeripherals:GPIO 2.2.0, Device:GD32F30x_StdPeripherals:I2C 2.2.0, Device:GD32F30x_StdPeripherals:MISC 2.2.0, Device:GD32F30x_StdPeripherals:PMU 2.2.0, Device:GD32F30x_StdPeripherals:RCU 2.2.0, Device:GD32F30x_StdPeripherals:RTC 2.2.0, Device:GD32F30x_StdPeripherals:SDIO 2.2.0, Device:GD32F30x_StdPeripherals:SPI_I2S 2.2.0, Device:GD32F30x_StdPeripherals:TIMER 2.2.0, Device:GD32F30x_StdPeripherals:USART 2.1.0, Device:GD32F30x_StdPeripherals:WWDGT 2.2.0, Device:GD32F30x_libopt 2.2.0, Device:Startup 2.2.0
